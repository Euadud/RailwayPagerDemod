options:
  parameters:
    generate_options: qt_gui
    id: tcp_out
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '800000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '128.0'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jason/Desktop/out.sdriq
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '127.5'
    scale: '127.5'
    vlen: '1'
  states: {state: disabled}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters:
    bias: '127.5'
    scale: '127.5'
    vlen: '1'
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleave_1
  id: blocks_interleave
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '127.0'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 500e3
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jason/Desktop/baseband_820836013Hz_21-57-47_09-02-2025.wav
    repeat: 'False'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Print float samples to console"""

          def __init__(self, print_every=1000):
              """
              Parameters:
              print_every -- how often to print (avoid flooding console)
              """
              gr.sync_block.__init__(
                  self,
                  name='Float Printer',
                  in_sig=[np.float32],
                  out_sig=None  # 不输出
              )
              self.print_every = int(print_every)
              self.count = 0

          def work(self, input_items, output_items):
              samples = input_items[0]
              for s in samples:
                  if self.count % self.print_every == 0:
                      print(f"{s:.6f}")
                  self.count += 1
              return len(samples)
    print_every: '1'
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1000000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_1, '0']
- [blocks_add_const_vxx_1, '0', blocks_float_to_char_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_uchar_1, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_2, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_char_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_char_1, '0', blocks_interleave_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_interleave_1, '0']
- [blocks_float_to_uchar_1, '0', blocks_interleave_1, '1']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_1, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
