options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: hackrf_tcp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '0b10000000'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '0b10000000'
    type: byte
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jason/Desktop/iq3.sdriq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jason/Downloads/20251014-105228_z385_RTLSDR_821237500Hz_2MSps.iq
    offset: '233578496'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Print float samples to console"""

          def __init__(self, print_every=1000):
              """
              Parameters:
              print_every -- how often to print (avoid flooding console)
              """
              gr.sync_block.__init__(
                  self,
                  name='Float Printer',
                  in_sig=[np.int8],
                  out_sig=None  # 不输出
              )
              self.print_every = int(print_every)
              self.count = 0

          def work(self, input_items, output_items):
              samples = input_items[0]
              for s in samples:
                  if self.count % self.print_every == 0:
                      print(f"{s:.6f}")
                  self.count += 1
              return len(samples)
    print_every: '1'
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1234'
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '30'
    freq0: '821237500'
    gain0: '14'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_const_vxx_1, '0', network_tcp_sink_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_complex_to_interleaved_char_0, '0', epy_block_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', network_tcp_sink_0, '0']
- [blocks_file_source_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_interleaved_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
